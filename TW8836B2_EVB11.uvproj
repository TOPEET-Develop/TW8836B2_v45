# Keil uVision project TW8836B2_EVB11.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: TW8836B_EVB11 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: EVB_11 nullFn="//"
  c include: SiI-SW;SiI-SW\HAL;SiI-SW\DEBUG;SiI-SW\CEC;.\Source36\LIB
  link misc: RECURSIONS (30)
  group Source Group 1
    source36/: CPU.c Util.c Printf.c Release.txt
    ./Source36/: L51_BANK.A51 8051.txt
  group Bank0
    source36/: main.c SPI.c i2c.c Decoder.c measure.c Scaler.c InputCtrl.c ImageCtrl.c Settings.c EEPROM.c Remo.c TouchKey.c HID.c DTV.c misc.c HDMI_EP907M.c
    ./Source36/: BT656.c aRGB.c I2cSpi.c
    ./Source36/LIB/: E3PROM_C24.LIB
  group Bank1
    source36/: monitor.c Monitor_MCU.c monitor_SPI.c monitor_menu.c DebugMsg.c
  group Bank2
    source36/: OSDFont.c OSDSPI.c FOsdString.c FOsdTable.c FOsdDisplay.c FOsdMenu.c SOsdMenu.c
    ./Source36/: SpiFlashMap.c SOsdMenuMap.c
  group Bank3
    source36/: DemoMain.c test_FOSD.c
    ./Source36/: InitReg.c
